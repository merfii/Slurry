# Keil uVision project Slurry.uvprojx, settings and files
target LaserMCU (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Slurry +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: User;Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: delay.c delay.h main.c reboot.h utils.h
    ./: utils.c
  group Driver
    ./Driver/: Comm.c Comm.h Flicker.c Flicker.h Key.c Key.h Laser.c Laser.h Led.c Led.h Meter.c Meter.h Trigger.c Trigger.h usart.c usart.h Watchdog.c Watchdog.h
    ./RTE/: stm32f10x_it.c stm32f10x_it.h
software components: CMSIS:CORE 5.0.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
